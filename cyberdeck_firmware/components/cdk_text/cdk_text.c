#include "cdk_text.h"

/* ------------------------------------------------------------------ */
/* UTF-8                                                              */
/* ------------------------------------------------------------------ */

void cdk_utf8_reset(cdk_utf8_t *d)
{
    d->acc = 0;
    d->need = 0;
    d->seen = 0;
    d->min = 0;
}

cdk_utf8_status_t cdk_utf8_feed(cdk_utf8_t *d, uint8_t b, uint32_t *cp, bool *retry)
{
    if (retry != NULL) {
        *retry = false;
    }

    if (d->need == 0) {
        if (b < 0x80u) {
            *cp = b;
            return CDK_UTF8_OK;
        }
        if ((b & 0xE0u) == 0xC0u) {
            d->acc = (uint32_t)(b & 0x1Fu);
            d->need = 1;
            d->min = 0x80u;
        } else if ((b & 0xF0u) == 0xE0u) {
            d->acc = (uint32_t)(b & 0x0Fu);
            d->need = 2;
            d->min = 0x800u;
        } else if ((b & 0xF8u) == 0xF0u) {
            d->acc = (uint32_t)(b & 0x07u);
            d->need = 3;
            d->min = 0x10000u;
        } else {
            /* 継続バイトが単独で来た、または 5 バイト以上の不正な先頭 */
            *cp = CDK_REPLACEMENT;
            return CDK_UTF8_INVALID;
        }
        d->seen = 1;
        return CDK_UTF8_NEED;
    }

    if ((b & 0xC0u) != 0x80u) {
        /* 継続バイトのはずが違うものが来た。今まで溜めたぶんを捨てて、
         * このバイトは新しい文字の先頭かもしれないので呼び側に返す。 */
        cdk_utf8_reset(d);
        *cp = CDK_REPLACEMENT;
        if (retry != NULL) {
            *retry = true;
        }
        return CDK_UTF8_INVALID;
    }

    d->acc = (d->acc << 6) | (uint32_t)(b & 0x3Fu);
    d->seen++;
    if (--d->need > 0) {
        return CDK_UTF8_NEED;
    }

    const uint32_t v = d->acc;
    const uint32_t min = d->min;
    cdk_utf8_reset(d);

    /* 冗長符号化、サロゲート、範囲外を弾く */
    if (v < min || (v >= 0xD800u && v <= 0xDFFFu) || v > 0x10FFFFu) {
        *cp = CDK_REPLACEMENT;
        return CDK_UTF8_INVALID;
    }
    *cp = v;
    return CDK_UTF8_OK;
}

size_t cdk_utf8_decode(const uint8_t *p, size_t len, uint32_t *cp, bool *ok)
{
    cdk_utf8_t d;
    cdk_utf8_reset(&d);

    for (size_t i = 0; i < len; i++) {
        bool retry = false;
        const cdk_utf8_status_t st = cdk_utf8_feed(&d, p[i], cp, &retry);
        if (st == CDK_UTF8_OK) {
            if (ok != NULL) {
                *ok = true;
            }
            return i + 1;
        }
        if (st == CDK_UTF8_INVALID) {
            if (ok != NULL) {
                *ok = false;
            }
            /* retry のときはそのバイトを消費していない */
            return retry ? i : i + 1;
        }
    }

    /* 途中で切れた */
    if (ok != NULL) {
        *ok = false;
    }
    return 0;
}

size_t cdk_utf8_encode(uint32_t cp, uint8_t *out)
{
    if (cp > 0x10FFFFu || (cp >= 0xD800u && cp <= 0xDFFFu)) {
        cp = CDK_REPLACEMENT;
    }
    if (cp < 0x80u) {
        out[0] = (uint8_t)cp;
        return 1;
    }
    if (cp < 0x800u) {
        out[0] = (uint8_t)(0xC0u | (cp >> 6));
        out[1] = (uint8_t)(0x80u | (cp & 0x3Fu));
        return 2;
    }
    if (cp < 0x10000u) {
        out[0] = (uint8_t)(0xE0u | (cp >> 12));
        out[1] = (uint8_t)(0x80u | ((cp >> 6) & 0x3Fu));
        out[2] = (uint8_t)(0x80u | (cp & 0x3Fu));
        return 3;
    }
    out[0] = (uint8_t)(0xF0u | (cp >> 18));
    out[1] = (uint8_t)(0x80u | ((cp >> 12) & 0x3Fu));
    out[2] = (uint8_t)(0x80u | ((cp >> 6) & 0x3Fu));
    out[3] = (uint8_t)(0x80u | (cp & 0x3Fu));
    return 4;
}

/* ------------------------------------------------------------------ */
/* 文字幅                                                              */
/* ------------------------------------------------------------------ */

typedef struct {
    uint32_t lo;
    uint32_t hi;
} range_t;

/* East Asian Width = Wide または Fullwidth。Unicode 15 相当。 */
static const range_t k_wide[] = {
    {0x1100, 0x115F}, {0x231A, 0x231B}, {0x2329, 0x232A}, {0x23E9, 0x23EC},
    {0x23F0, 0x23F0}, {0x23F3, 0x23F3}, {0x25FD, 0x25FE}, {0x2614, 0x2615},
    {0x2630, 0x2637}, {0x2648, 0x2653}, {0x267F, 0x267F}, {0x268A, 0x268F},
    {0x2693, 0x2693}, {0x26A1, 0x26A1}, {0x26AA, 0x26AB}, {0x26BD, 0x26BE},
    {0x26C4, 0x26C5}, {0x26CE, 0x26CE}, {0x26D4, 0x26D4}, {0x26EA, 0x26EA},
    {0x26F2, 0x26F3}, {0x26F5, 0x26F5}, {0x26FA, 0x26FA}, {0x26FD, 0x26FD},
    {0x2705, 0x2705}, {0x270A, 0x270B}, {0x2728, 0x2728}, {0x274C, 0x274C},
    {0x274E, 0x274E}, {0x2753, 0x2755}, {0x2757, 0x2757}, {0x2795, 0x2797},
    {0x27B0, 0x27B0}, {0x27BF, 0x27BF}, {0x2B1B, 0x2B1C}, {0x2B50, 0x2B50},
    {0x2B55, 0x2B55}, {0x2E80, 0x2E99}, {0x2E9B, 0x2EF3}, {0x2F00, 0x2FD5},
    {0x2FF0, 0x2FFB}, {0x3000, 0x303E}, {0x3041, 0x3096}, {0x3099, 0x30FF},
    {0x3105, 0x312F}, {0x3131, 0x318E}, {0x3190, 0x31E3}, {0x31F0, 0x321E},
    {0x3220, 0x3247}, {0x3250, 0x4DBF}, {0x4E00, 0xA48C}, {0xA490, 0xA4C6},
    {0xA960, 0xA97C}, {0xAC00, 0xD7A3}, {0xF900, 0xFAFF}, {0xFE10, 0xFE19},
    {0xFE30, 0xFE52}, {0xFE54, 0xFE66}, {0xFE68, 0xFE6B}, {0xFF01, 0xFF60},
    {0xFFE0, 0xFFE6},
    /* BMP 外。グリフは持たないが、幅だけは正しく数える必要がある。 */
    {0x16FE0, 0x16FE4}, {0x17000, 0x18CD5}, {0x1B000, 0x1B152},
    {0x1B164, 0x1B167}, {0x1B170, 0x1B2FB}, {0x1F004, 0x1F004},
    {0x1F0CF, 0x1F0CF}, {0x1F18E, 0x1F18E}, {0x1F191, 0x1F19A},
    {0x1F200, 0x1F320}, {0x1F32D, 0x1F335}, {0x1F337, 0x1F37C},
    {0x1F37E, 0x1F393}, {0x1F3A0, 0x1F3CA}, {0x1F3CF, 0x1F3D3},
    {0x1F3E0, 0x1F3F0}, {0x1F3F4, 0x1F3F4}, {0x1F3F8, 0x1F43E},
    {0x1F440, 0x1F440}, {0x1F442, 0x1F4FC}, {0x1F4FF, 0x1F53D},
    {0x1F54B, 0x1F54E}, {0x1F550, 0x1F567}, {0x1F57A, 0x1F57A},
    {0x1F595, 0x1F596}, {0x1F5A4, 0x1F5A4}, {0x1F5FB, 0x1F64F},
    {0x1F680, 0x1F6C5}, {0x1F6CC, 0x1F6CC}, {0x1F6D0, 0x1F6D2},
    {0x1F6D5, 0x1F6D7}, {0x1F6EB, 0x1F6EC}, {0x1F6F4, 0x1F6FC},
    {0x1F7E0, 0x1F7EB}, {0x1F90C, 0x1F93A}, {0x1F93C, 0x1F945},
    {0x1F947, 0x1F9FF}, {0x1FA70, 0x1FAFF}, {0x20000, 0x2FFFD},
    {0x30000, 0x3FFFD},
};

/* ゼロ幅。結合文字と各種フォーマット文字。 */
static const range_t k_zero[] = {
    {0x0300, 0x036F}, {0x0483, 0x0489}, {0x0591, 0x05BD}, {0x05BF, 0x05BF},
    {0x0610, 0x061A}, {0x064B, 0x065F}, {0x0670, 0x0670}, {0x06D6, 0x06DC},
    {0x0711, 0x0711}, {0x0730, 0x074A}, {0x07A6, 0x07B0}, {0x0816, 0x0819},
    {0x08E3, 0x0903}, {0x093A, 0x093C}, {0x0941, 0x0948}, {0x094D, 0x094D},
    {0x0951, 0x0957}, {0x0E31, 0x0E31}, {0x0E34, 0x0E3A}, {0x0E47, 0x0E4E},
    {0x1AB0, 0x1AFF}, {0x1DC0, 0x1DFF}, {0x200B, 0x200F}, {0x202A, 0x202E},
    {0x2060, 0x2064}, {0x206A, 0x206F}, {0x20D0, 0x20F0}, {0xFE00, 0xFE0F},
    {0xFE20, 0xFE2F}, {0xFEFF, 0xFEFF}, {0xFFF9, 0xFFFB},
    {0xE0100, 0xE01EF},
};

/* East Asian Width = Ambiguous のうち、実際に問題になりやすいもの。
 * 罫線素片、ギリシャ文字、キリル文字、丸数字など。
 * 端末の既定では半角として扱う。 */
static const range_t k_ambiguous[] = {
    {0x00A1, 0x00A1}, {0x00A4, 0x00A4}, {0x00A7, 0x00A8}, {0x00AA, 0x00AA},
    {0x00AD, 0x00AE}, {0x00B0, 0x00B4}, {0x00B6, 0x00BA}, {0x00BC, 0x00BF},
    {0x00C6, 0x00C6}, {0x00D0, 0x00D0}, {0x00D7, 0x00D8}, {0x00DE, 0x00E1},
    {0x00E6, 0x00E6}, {0x00E8, 0x00EA}, {0x00EC, 0x00ED}, {0x00F0, 0x00F0},
    {0x00F2, 0x00F3}, {0x00F7, 0x00FA}, {0x00FC, 0x00FC}, {0x00FE, 0x00FE},
    {0x0391, 0x03A9}, {0x03B1, 0x03C9}, {0x0401, 0x0401}, {0x0410, 0x044F},
    {0x0451, 0x0451}, {0x2010, 0x2010}, {0x2013, 0x2016}, {0x2018, 0x2019},
    {0x201C, 0x201D}, {0x2020, 0x2022}, {0x2024, 0x2027}, {0x2030, 0x2030},
    {0x2032, 0x2033}, {0x2035, 0x2035}, {0x203B, 0x203B}, {0x2074, 0x2074},
    {0x207F, 0x207F}, {0x2081, 0x2084}, {0x20AC, 0x20AC}, {0x2103, 0x2103},
    {0x2105, 0x2105}, {0x2109, 0x2109}, {0x2113, 0x2113}, {0x2116, 0x2116},
    {0x2121, 0x2122}, {0x2126, 0x2126}, {0x212B, 0x212B}, {0x2153, 0x2154},
    {0x215B, 0x215E}, {0x2160, 0x216B}, {0x2170, 0x2179}, {0x2189, 0x2189},
    {0x2190, 0x2199}, {0x21B8, 0x21B9}, {0x21D2, 0x21D2}, {0x21D4, 0x21D4},
    {0x21E7, 0x21E7}, {0x2200, 0x2200}, {0x2202, 0x2203}, {0x2207, 0x2208},
    {0x220B, 0x220B}, {0x220F, 0x220F}, {0x2211, 0x2211}, {0x2215, 0x2215},
    {0x221A, 0x221A}, {0x221D, 0x2220}, {0x2223, 0x2223}, {0x2225, 0x2225},
    {0x2227, 0x222C}, {0x222E, 0x222E}, {0x2234, 0x2237}, {0x223C, 0x223D},
    {0x2248, 0x2248}, {0x224C, 0x224C}, {0x2252, 0x2252}, {0x2260, 0x2261},
    {0x2264, 0x2267}, {0x226A, 0x226B}, {0x226E, 0x226F}, {0x2282, 0x2283},
    {0x2286, 0x2287}, {0x2295, 0x2295}, {0x2299, 0x2299}, {0x22A5, 0x22A5},
    {0x22BF, 0x22BF}, {0x2312, 0x2312}, {0x2460, 0x24E9}, {0x24EB, 0x254B},
    {0x2550, 0x2573}, {0x2580, 0x258F}, {0x2592, 0x2595}, {0x25A0, 0x25A1},
    {0x25A3, 0x25A9}, {0x25B2, 0x25B3}, {0x25B6, 0x25B7}, {0x25BC, 0x25BD},
    {0x25C0, 0x25C1}, {0x25C6, 0x25C8}, {0x25CB, 0x25CB}, {0x25CE, 0x25D1},
    {0x25E2, 0x25E5}, {0x25EF, 0x25EF}, {0x2605, 0x2606}, {0x2609, 0x2609},
    {0x260E, 0x260F}, {0x261C, 0x261C}, {0x261E, 0x261E}, {0x2640, 0x2640},
    {0x2642, 0x2642}, {0x2660, 0x2661}, {0x2663, 0x2665}, {0x2667, 0x266A},
    {0x266C, 0x266D}, {0x266F, 0x266F}, {0x273D, 0x273D}, {0x2776, 0x277F},
    {0xFFFD, 0xFFFD},
};

static bool in_ranges(const range_t *r, size_t n, uint32_t cp)
{
    size_t lo = 0;
    size_t hi = n;
    while (lo < hi) {
        const size_t mid = lo + (hi - lo) / 2;
        if (cp < r[mid].lo) {
            hi = mid;
        } else if (cp > r[mid].hi) {
            lo = mid + 1;
        } else {
            return true;
        }
    }
    return false;
}

int cdk_char_width(uint32_t cp)
{
    /* C0 / C1 制御文字。端末側で解釈するのでセルは使わない。 */
    if (cp < 0x20u || (cp >= 0x7Fu && cp < 0xA0u)) {
        return 0;
    }
    if (cp < 0x0300u) {
        return 1; /* よくある道を先に抜ける */
    }
    if (in_ranges(k_zero, sizeof(k_zero) / sizeof(k_zero[0]), cp)) {
        return 0;
    }
    if (in_ranges(k_wide, sizeof(k_wide) / sizeof(k_wide[0]), cp)) {
        return 2;
    }
    return 1;
}

bool cdk_char_ambiguous(uint32_t cp)
{
    return in_ranges(k_ambiguous, sizeof(k_ambiguous) / sizeof(k_ambiguous[0]), cp);
}
